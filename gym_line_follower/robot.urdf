Commit message: ppo_runtime configuration file

File: gym_line_follower/robot.urdf (robot description, URDF)
Before this commit: robot follower, 5 links, 4 joints
Joints:
- joint chassis_to_caster: origin xyz=-0.081 0 -0.004 rpy=-1.5708 0 0 -> xyz=0.081 0 -0.004 rpy=-1.5708 0 0
